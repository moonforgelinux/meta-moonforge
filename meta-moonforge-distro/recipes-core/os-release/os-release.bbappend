#
# SPDX-License-Identifier: MIT
# SPDX-FileCopyrightText: 2025-2026 Igalia S.L.
#

OS_RELEASE_FIELDS += " \
    IMAGE_ID \
    IMAGE_VERSION \
"

OS_RELEASE_UNQUOTED_FIELDS += " \
    IMAGE_ID \
    IMAGE_VERSION \
"
