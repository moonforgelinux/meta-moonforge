#
# SPDX-License-Identifier: MIT
# SPDX-FileCopyrightText: 2025 Igalia S.L.
#

SPLASH_IMAGES = "file://logo-moonforge.png;outsuffix=default"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
