CORE_IMAGE_EXTRA_INSTALL += " \
    docker-moby \
    docker-compose \
    docker-config \
"
