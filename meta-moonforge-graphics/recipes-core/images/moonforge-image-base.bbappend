IMAGE_FEATURES += " \
    weston \
"

CORE_IMAGE_EXTRA_INSTALL += " \
    polkit \
    gsettings-desktop-schemas \
"
