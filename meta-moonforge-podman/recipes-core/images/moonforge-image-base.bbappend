CORE_IMAGE_EXTRA_INSTALL += " \
    podman \
    podman-compose \
    ca-certificates \
"
