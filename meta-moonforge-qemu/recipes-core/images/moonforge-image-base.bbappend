WKS_FILE_DEPENDS:remove = "systemd-boot"
