CORE_IMAGE_EXTRA_INSTALL += " \
    rauc-update \
"
