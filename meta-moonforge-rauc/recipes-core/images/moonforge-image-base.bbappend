CORE_IMAGE_EXTRA_INSTALL += " \
    kernel-image \
    kernel-modules \
    rauc \
"
