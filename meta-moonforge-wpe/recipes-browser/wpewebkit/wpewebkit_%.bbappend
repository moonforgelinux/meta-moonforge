PACKAGECONFIG:append = " wpe-platform"