CORE_IMAGE_EXTRA_INSTALL += " \
    wpe-simple-launcher \
"
